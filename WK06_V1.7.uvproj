# Keil uVision project WK06_V1.7.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: WK06V1.7 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\BSP\Inc;.\Core\Inc;.\Drivers;.\Emembed\Inc;.\Emembed\Inc;.\Middlewares;.\SYSTEM
  group START
    ./: STARTUP.A51
  group Core
    ./Core/Src/: adc.c delay.c eeprom.c gpio.c main.c pwm.c timer.c uart.c
  group BSP
    ./BSP/Src/: interrupt.c ntc.c pwmset.c serial_comport.c
  group Emembed
    ./Emembed/Src/: eeprom_read_write.c power_crl.c wind_crl.c screen.c temp_monitor.c
